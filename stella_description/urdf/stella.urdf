Commit message: Update stella.urdf

File: stella_description/urdf/stella.urdf (robot description, URDF)
Before this commit: robot stella, 4 links, 3 joints
Joints:
- joint scan_joint: origin xyz=0.06 0.0 0.14 rpy=0.0 0.0 0.0 -> xyz=0.06 0.0 0.159 rpy=0.0 0.0 0.0
